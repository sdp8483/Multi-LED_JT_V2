# Repository sdp8483/Multi-LED_JT_V2

File README.md:

# Multi-LED Joule Thief V2

KiCAD Schematic, PCB layout, GERBER files, and images.

Blog Post: https://samueldperry.com/2017/12/25/multi-led-joule-thief-v2/

## KiCad design Multi-LED_JT_V2.kicad_pcb

Parts:
BT1: Battery_Cell; AA_PCB-Clip; Mfg Part Number BK-92
D1, D2, D3, D4, D5, D6: LED; LED_Luminus_MP-2016; Mfg Part Number MP-2016-1100-65-70
L1: SRF4532-510Y; Mfg Part Number SRF4532-510Y
Q1: BC817-25; SOT-23; Mfg Part Number BC817-25-TP
R1: 6.8K; R_0603; Mfg Part Number RC0603JR-076K8L
SW1: SW_DPDT; DPDT_JS202011JAQN; Mfg Part Number JS102011JAQN

Connections:
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), Q1.2 (E), SW1.2
unnamed: BT1.1 (+), L1.1, L1.3
unnamed: BT1.2 (-), SW1.3
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), L1.2, Q1.3 (C)
unnamed: L1.4, R1.1
unnamed: Q1.1 (B), R1.2

Notes on the sheet:
JS202011JCQN OUT OF STOCK DIRECT REPLACEMENT IS JS102011JAQN SPST, SAME FOOTPRINT

Board: 2 copper layers, 54.1 x 14.5 mm, 12 parts (2 on the bottom side), 6 nets.

Other parts of the board:
LOGO: P-Logo_Small

## Commit log

2017-10-23 copy lib from candle project
2017-10-23 copy footprints from candle project
2017-10-24 ignore kicad bom output
2017-10-26 add datasheets
2017-10-26 no need for dummy
2017-10-26 add LED footprint
2017-10-26 finish up schema
2017-11-08 add led datasheet
2017-11-08 edit battery clip outline
2017-11-08 remove switch
2017-11-08 D1 Annode not connected
2017-11-08 perliminary PCB layout
2017-11-08 initial gerber output
2017-11-08 D1 anode not connected
2017-11-08 output to gerber, oshpark order 1
2017-11-27 add DPDT JS202011JAQN switch
2017-11-27 OS series switch not used in design
2017-11-27 add JS202011JAQN footprint
2017-11-27 CvPCB assosiate DPDT footprint
2017-11-27 associated wrong footprint
2017-11-27 add DPDT switch
2017-11-27 no net fill back and front
2017-11-27 new Gerber output
2017-11-27 SVG front Cu output
2017-11-27 GIMP pcb image
2017-11-27 no dummies here
2017-11-27 add no fill zones
2017-11-27 Zip for OSH Stencils Upload
2017-11-27 Fpaste for stencil
2017-11-27 no need for zip
2017-11-27 JS202011JCQN is out of stock, JS102011JAQN is replacment
2017-11-27 save changes to project file
2017-12-02 set SW1 reference to invisible
2017-12-02 add to f.SilkS ON with arrow indicator
2017-12-02 round pcb corners
2017-12-10 update SRF4532 silkscreen
2017-12-10 update gerber files for pcb manufacture
2017-12-10 ignore zip files in gerber folder
2017-12-10 update inductor silkscreen
2017-12-10 update lib
2017-12-24 product images
2017-12-28 wb adjust images
2017-12-28 update readme for correct repository
2017-12-28 fix markup for header
